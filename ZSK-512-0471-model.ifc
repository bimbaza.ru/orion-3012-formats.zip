Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:48+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-512-0471
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-512-0471 Тематический игровой комплекс «Пожарная бригада»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс «Пожарная бригада»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-512-0471; ModelReference: Тематический игровой комплекс «Пожарная бригада»; ProductionYear: 2026; ArticleNumber: ZSK-512-0471
ORION_Изделие - Артикул: ZSK-512-0471; Артикул прежний: SD-512-0471; Наименование: Тематический игровой комплекс «Пожарная бригада»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: По запросу; Зона безопасности: 10.6 x 11.0 м; Высота свободного падения: По запросу; Возраст: для детей от 5 до 12 лет; Цена: 6 063 520 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/transport/3012; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс «Пожарная бригада»; ADSK_Марка: ZSK-512-0471; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/transport/3012
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 5 до 12 лет; ZSK_Зона_безопасности: 10.6 x 11.0 м; ZSK_Высота_свободного_падения: По запросу; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-512-0471
